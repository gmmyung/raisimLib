Commit message: multiple images

File: rsc/raibo2_with_head/urdf/raibo2.urdf (robot description, URDF)
Before this commit: robot raibo2, 22 links, 21 joints
Links:
- removed link d435i_front
Joints:
- removed joint d435i_front_joint
